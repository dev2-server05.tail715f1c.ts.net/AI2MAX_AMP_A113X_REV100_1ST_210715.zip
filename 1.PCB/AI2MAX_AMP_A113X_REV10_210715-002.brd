# Allegro board AI2MAX_AMP_A113X_REV10_210715-002.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC5V: length 175
  TOP w0.25: v1(22.85,10.2) R10.2 C10.2
  TOP w0.3: v1(83.53,21.27) 85.1,19.7 87.5,19.7 88.1,19.1 88.35,19.1 88.6,18.85 93.45,18.85 94.25,19.65 95.35,19.65 95.75,19.25 v1(95.75,19.1) ; v1(80.2,38.3) 80.1,38.4 80.1,40.25 79.35,41 UNK5R5.1
  TOP w0.4: v1(62.15,9.95) v1(62.75,9.35) ; v1(52.05,9.95) v1(52.65,9.35)
  TOP w0.5: v1(62.75,9.95) 61.9,10.8 C68.1 ; v1(62.75,9.95) v1(62.75,9.35) v1(62.15,9.35) v1(62.15,9.95) ; v1(62.75,9.95) v1(62.15,9.95) ; v1(52.65,9.95) v1(52.05,9.95) ; v1(52.65,9.95) 51.8,10.8 51.2,10.8 ; v1(52.65,9.95) v1(52.65,9.35) v1(52.05,9.35) ; v1(52.05,9.95) 51.2,10.8 ; v1(52.05,9.95) v1(51.45,9.95) ; v1(52.05,9.95) 52.05,9.65 ; 50.4,10.1 50.67,10.37 ; 50.4,10.1 50.4,10.75 50.35,10.8 ; 50.4,10.1 R52.2 ; 50.4,10.1 49.7,10.8 ; 50.4,10.1 50.55,9.95 v1(51.45,9.95) ; 50.67,10.37 C57.1 ; 50.67,10.37 51.03,10.37 v1(51.45,9.95) ; 51.2,10.8 C57.1 ; v1(51.45,9.95) 51.45,10.45 C57.1 ; v1(51.45,9.95) v1(51.45,9.35) ; 49.7,10.8 C58.2 U52.5 ; 49.7,10.8 50.35,10.8 ; v1(62.15,9.95) 61.3,10.8 ; v1(62.15,9.95) 62.15,10.45 C68.1 ; 61.3,10.8 C68.1 ; 61.3,10.8 C69.2 U53.5 ; C57.1 50.35,10.8 ; R52.2 50.43,9.35 v1(51.45,9.35) ; R52.2 50.67,9.65 52.05,9.65 ; 52.05,9.65 v1(52.05,9.35) ; v1(52.05,9.35) v1(51.45,9.35) ; v1(84.6,26.35) v1(84.6,32.3) v1(84.6,39.1)
  MID2(L3) w0.3: v1(22.85,10.2) 22.85,13.95 24.05,15.15 35,15.15 v1(40.25,9.9)
  MID2(L3) w0.5: v1(62.75,9.35) v1(62.15,9.35) ; v1(62.75,9.35) 63.1,9.35 63.7,9.95 ; v1(62.75,9.35) 63.35,9.95 ; 63.7,9.95 64.05,9.95 ; 63.7,9.95 63.35,9.95 ; v1(84.6,26.35) 84.6,24.25 83.95,23.6 83.95,21.7 v1(83.53,21.27) 82.78,20.52 79.33,20.52 68.75,9.95 64.05,9.95 ; 64.05,9.95 62.85,8.75 ; 63.35,9.95 v1(62.75,9.95) ; v1(84.6,39.1) 81,39.1 v1(80.2,38.3)
  BOTTOM w0.1: 40.9,9.4 40.35,9.4 v1(40.25,9.3) ; 40.9,9.4 v1(40.9,9.9) 40.9,10 40.35,10 v1(40.25,9.9) v1(40.25,9.3) ; 40.9,9.4 v1(40.9,9.3) v1(40.9,8.7) v1(40.25,8.7) v1(40.25,9.3) ; v1(84.6,32.3) 84.4,32.1 R329.1 84.35,31.35 R330.1
  BOTTOM w0.2: R337.2 v1(52.65,9.35) ; R18.1 41.85,7.55 R6.2
  BOTTOM w0.25: C13.1 42.1,10.4 R6.2 ; R17.1 40.25,11 v1(40.25,9.9)
  BOTTOM w0.4: J814.1 UNK5C13.2 102.75,7.55 100.2,10.1 97.6,10.1 95.75,11.95 v1(95.75,19.1)
  BOTTOM w0.5: v1(62.15,9.95) v1(62.15,9.35) v1(62.75,9.35) ; v1(62.15,9.95) v1(62.75,9.35) ; v1(62.15,9.95) v1(62.75,9.95) v1(62.75,9.35) ; U51.5 C52.2 C51.1 52.65,10.45 v1(52.65,9.95) ; v1(84.6,39.1) 85.6,38.1 R334.1 ; U3.5 C14.2
VCC_3.3V: length 71.6
  TOP w0.25: UNK4U5.1 44.64,29.31 UNK4C5.1 ; v1(50.05,30.34) 50.14,30.43 UNK4U5.12 ; UNK4U5.24 56.14,29.71 UNK4C4.2 ; v1(50.08,52.33) 50.14,52.27 UNK4U5.37
  TOP w0.254: U1.A5 66.89,51.17 v2(66.95,51.23) ; v2(73.68,45.21) 73.39,44.92 U1.K15
  TOP w0.3: v1(56.15,28.8) UNK4C4.2 ; UNK4U9.T10 v1(51,40.6) 51.01,40.59 UNK4U9.U9 ; UNK4U9.N5 v1(49.5,42.1) 49.51,42.11 UNK4U9.M6
  TOP w0.406: v2(66.14,56.26) 66.14,53.6 66.95,52.78 v2(66.95,51.23)
  TOP w0.5: 44.65,29.05 v1(44.65,28.45) v1(45.25,28.45) 44.65,29.05 ; 44.65,29.05 UNK4C5.1 ; UNK4C4.2 57.35,29.7 57.65,30 v1(57.65,33) ; v1(85.2,51.7) v1(85.2,54.15) ; v1(45.5,62.35) v1(45.5,59.1)
  MID2(L3) w0.5: v1(85.2,51.7) 84.75,51.7 81.8,48.75 80.75,48.75 78.25,46.25 74.72,46.25 v2(73.68,45.21)
  BOTTOM w0.2: UNK2R18.1 v1(54.7,58.8) ; UNK2R19.1 v1(54.7,55.5)
  BOTTOM w0.3: UNK4C8.2 50.06,52.3 v1(50.08,52.33)
  BOTTOM w0.381: v2(66.95,51.23) 66.85,51.13 UNK2C22.2 ; v2(73.68,45.21) 73.92,44.98 UNK5C10.2
  BOTTOM w0.4: UNK4C18.2 51.25,40.35 v1(51,40.6) ; UNK4C17.2 v1(49.5,42.1)
  BOTTOM w0.5: 44.65,29.55 44.95,29.25 ; 44.65,29.55 v1(44.65,28.45) 44.95,28.45 ; 44.65,29.55 C22.1 Q1.3 ; 44.95,29.25 44.95,28.45 ; 44.95,29.25 45.25,28.95 v1(45.25,28.45) 44.95,28.45 ; v1(56.15,28.8) 50.35,28.8 50.05,29.1 UNK4C49.2 v1(50.05,30.34) ; U55.3 57.6,32.95 v1(57.65,33) 58,33.35 58,34.5 C79.1 U55.1 56.25,34.85 55.05,36.05 v1(54.25,36.05) UNK4R6.2 ; UNK2T15.1 44.5,63.35 v1(45.5,62.35)
VDD_EE: length 111.8
  TOP w0.2: v1(39.8,22.65) 40,22.45 v1(40,19.3) ; R53.2 C64.2 UNK1R2.2 45.4,5.05 v1(45.2,5.05)
  TOP w0.254: 67.52,45.55 67.28,45.8 67.12,45.8 U1.J5 ; 67.52,45.55 U1.J6 ; 67.52,45.55 67.27,45.3 67.23,45.3 v2(67.22,45.29) 67.2,45.26 U1.J5 ; U1.J5 v2(66.56,45.86) U1.J4 v2(65.91,45.85) U1.J3
  TOP w0.3: U1.K11 v2(70.47,45.24) ; U1.F12 v2(71.12,47.2)
  TOP w0.5: v1(57.65,45.75) v1(57.65,45.15)
  MID2(L3) w0.2: 51.35,15.2 v1(50.9,15.65) ; 51.35,15.2 51.65,15.2 ; 51.35,15.2 51.65,15.5 ; 51.35,15.2 51.65,14.9 ; 51.35,15.2 51.35,15.8 ; v1(50.9,16.25) 51.35,15.8 ; 51.35,15.8 51.65,15.5 ; v1(83.1,26.35) 82.35,26.35 68.2,12.2 54.35,12.2 51.65,14.9 ; 51.65,15.2 51.65,14.9 ; 51.65,15.2 51.65,15.5
  MID2(L3) w0.3: v2(66.56,45.86) 69.85,45.86 v2(70.47,45.24)
  BOTTOM w0.1: 62.9,45.85 62.9,45.85 UNK2C11.2 ; UNK2C13.1 61.58,45.51 61.44,45.65
  BOTTOM w0.2: v2(71.12,47.2) 71.35,46.96 UNK2R27.2 ; v1(40,19.3) 38.8,18.1 R15.2 ; 50.9,15.05 50.9,12.15 50.1,11.35 50.1,5.95 49.2,5.05 v1(45.2,5.05) ; 50.9,15.05 50.9,15.5 ; 50.9,15.05 50.67,15.28 ; 50.67,15.28 50.9,15.5 ; 50.67,15.28 v1(50.3,15.65) ; 50.9,15.5 v1(50.9,15.65) ; R333.2 86.4,26.9 83.65,26.9 v1(83.1,26.35) ; v1(39.8,22.65) v1(50.6,22.65)
  BOTTOM w0.3: UNK2C16.2 70.66,46.74 v2(71.12,47.2) 71.37,47.45 UNK2C1.2
  BOTTOM w0.381: v2(67.22,45.29) 67.22,45.72 67.09,45.85 UNK2C20.2
  BOTTOM w0.4: UNK2C16.2 70.47,45.63 v2(70.47,45.24)
  BOTTOM w0.5: 58.15,45.65 v1(57.65,45.15) v1(57.65,45.75) 57.8,45.9 59.15,45.9 59.15,45.65 ; v1(50.3,16.25) v1(50.3,15.65) v1(50.9,15.65) ; v1(50.3,16.25) v1(50.9,15.65) ; v1(50.3,16.25) v1(50.9,16.25) v1(50.9,15.65)
  BOTTOM w0.508: UNK2C20.2 v2(65.91,45.85) 61.58,45.85 61.58,45.52
  BOTTOM w1.016: 61.44,45.65 58.15,45.65
VDDAO_3.3V: length 203.9
  TOP w0.1: UNK2R28.1 UNK2R24.1 v1(79.95,59.8)
  TOP w0.2: v1(63.75,11.2) 63.75,8.85 63.3,8.4 R62.1 ; 43.55,15.05 43.55,15.5 ; 43.55,15.05 43.55,13.75 44,13.3 44,6.35 44.42,5.92 v1(45.2,5.92) ; 43.55,15.05 43.33,15.28 ; 43.55,15.5 43.33,15.28 ; 43.55,15.5 v1(43.55,15.65) ; 43.33,15.28 v1(42.95,15.65)
  TOP w0.254: v2(73.07,44.59) U1.K14 ; U1.D13 72.09,48.82 v2(71.77,49.15)
  TOP w0.3: v1(92.7,58.25) 92.85,58.1 92.85,49.8 v1(92.95,49.7) ; v1(61.6,61.45) UNK2D7.1
  TOP w0.4: v1(61.25,52.25) 60.55,52.95 60.55,56.8 60.15,57.2 v1(60.15,58)
  TOP w0.5: v1(43.35,34.55) v1(43.35,35.15) ; v1(83.95,27.35) v1(83.95,32.3) v1(83.95,37.9) ; v1(43.55,16.25) v1(42.95,16.25) v1(42.95,15.65) ; v1(43.55,16.25) v1(42.95,15.65) ; v1(43.55,16.25) v1(43.55,15.65) v1(42.95,15.65) ; v3(74.05,56.05) 74.05,57.2 UNK2U2.3 74.73,59.37 v1(74.55,59.55) UNK2C15.2 ; v1(51.2,71.4) v1(50.6,71.4)
  MID2(L3) w0.2: 43.7,14.9 43.7,15.2 ; 43.7,14.9 43.7,12.55 45.05,11.2 v1(63.75,11.2) ; 43.7,14.9 43.4,15.2 ; 43.7,15.2 43.7,15.5 ; 43.7,15.2 43.4,15.2 ; 43.7,15.5 v1(43.55,15.65) 43.4,15.5 43.4,15.2 ; 43.7,15.5 43.4,15.2 ; v1(83.95,37.9) 87.95,37.9 92.55,42.5 92.55,49.3 v1(92.95,49.7) ; 43.4,15.2 v1(42.95,15.65)
  MID2(L3) w0.5: v1(96.1,26.12) 94.52,27.7 v1(93.35,27.7) 84.3,27.7 v1(83.95,27.35) ; 51.2,70.8 52.2,69.8 52.2,61 ; 51.2,70.8 v1(51.2,71.4) v1(50.6,71.4) 51.2,70.8 ; UNK2CON1.3 66.35,71.42 66.35,61.7
  BOTTOM w0.1: v1(83.95,32.3) 81.5,32.3 R336.1
  BOTTOM w0.2: v1(33.95,59.03) 33.93,59.01 R314.2 ; R307.1 33.93,25.12 v1(33.95,25.1) ; v1(96.1,26.12) 96.12,26.14 R214.2 ; R323.1 33.93,47.07 v1(33.95,47.05) ; C19.2 R8.2 47.5,6.8 46.63,5.92 v1(45.2,5.92)
  BOTTOM w0.254: UNK2C5.2 72.51,49.84 71.86,49.18 v2(71.77,49.15)
  BOTTOM w0.3: v1(36.55,35.45) C301.1 35.37,35.06 U301.40 ; v1(93.35,27.7) 93.39,27.74 C230.1 94.68,28.13 U202.40 ; UNK2C5.2 73.48,51.28 73.48,51.28 ; v1(92.95,49.7) 92.96,49.69 C201.1 94.68,50.08 U201.40 ; v1(36.8,57.4) C330.1 35.37,57.01 U302.40
  BOTTOM w0.305: C101.2 75.59,44.45 73.21,44.45 v2(73.07,44.59)
  BOTTOM w0.4: v1(78.55,61) 77.66,61 T129.1 T319.1 ; v1(61.25,52.25) 63.11,50.39 UNK2R2.1
  BOTTOM w0.5: v1(62.7,57.85) 62.7,56.86 R105.1 ; v1(83.95,37.9) 83.95,37.3 R335.1 83.65,37.15 82.7,36.2 79.8,36.2 79.3,36.7 79.3,39.4 77.27,41.43 77.27,42.77 C101.2 ; 41.8,34.5 R12.2 43.1,34.9 ; 41.8,34.5 42.7,34.5 ; 41.8,34.5 41.8,33.85 ; 41.8,34.5 C21.1 ; 43.1,34.9 v1(43.35,35.15) v1(43.35,34.55) 42.65,33.85 C21.1 ; 43.1,34.9 42.7,34.5 ; C21.1 C23.2 41.8,33.85 ; C21.1 42.65,32.3 Q1.2 ; 42.7,34.5 42.05,33.85 41.8,33.85 ; T316.1 51.85,67.9 C250.2 51.85,71.35 C249.1 v1(51.2,71.4) v1(50.6,71.4)
  BOTTOM w0.508: 73.48,51.28 74.32,52.12 74.32,55.78 v3(74.05,56.05)
VDDCPU: length 53.9
  TOP w0.2: 66.56,47.2 U1.F5 67.21,47.2 ; 66.56,47.2 U1.G5 ; 66.56,47.2 U1.G4 ; 67.21,47.2 v2(67.18,47.2) ; 67.21,47.2 U1.G6 ; 67.21,47.2 U1.F6 67.54,47.52 67.86,47.2 67.86,47.19 U1.G6 ; 67.21,47.2 U1.G5 ; U1.G5 67.21,46.59 v2(67.19,46.59) ; U1.G5 66.56,46.55 ; v2(65.92,46.6) U1.H4 66.56,46.55 ; v2(65.92,46.6) U1.G4 ; v2(65.92,46.6) U1.H3 ; v2(65.92,46.6) U1.G3 65.59,46.87 v2(65.91,47.2) U1.G4 ; U1.G6 U1.H5 66.56,46.55 ; U1.G6 67.86,46.55 67.87,46.55 v2(67.83,46.59) ; v1(58.95,6.3) 54.75,6.3 54.4,6.65 54.4,13.95 53.8,14.55 v1(53.8,15.05) ; U1.G4 66.4,46.71 ; U1.G4 66.4,46.71 ; 66.4,46.71 66.56,46.55 ; 66.56,46.55 v2(66.58,46.59)
  TOP w0.5: v1(53.2,15.65) v1(53.2,15.05) v1(53.8,15.05) ; v1(53.2,15.65) v1(53.8,15.05) ; v1(53.2,15.65) v1(53.2,16.25) ; v1(53.2,15.65) v1(53.8,15.65) ; v1(53.2,16.25) v1(53.8,16.25) v1(53.8,15.65) ; v1(53.2,16.25) v1(53.8,15.65) ; v1(58.05,50.1) v1(58.05,50.7) ; v1(58.05,50.1) v1(58.65,50.1) ; v1(58.05,50.1) v1(57.45,50.1) v1(57.45,50.7) ; v1(58.05,50.1) v1(57.45,50.7) ; v1(58.05,50.7) v1(57.45,50.7) ; v1(58.05,50.7) v1(58.65,50.7) v1(58.65,50.1) ; v1(58.05,50.7) v1(58.65,50.1) ; v1(53.8,15.05) v1(53.8,15.65)
  BOTTOM w0.1: UNK2C7.2 63.22,46.91 63.2,46.89 ; 65.4,46.89 65.38,46.91 UNK2C14.2 ; 66.7,46.54 66.65,46.59 v2(66.58,46.59) ; v2(67.18,47.2) UNK2C19.2 ; 64.3,46.89 64.31,46.9 UNK2C8.2 ; UNK2C6.1 UNK2C4.1 ; v2(65.91,47.2) 65.91,46.61 v2(65.92,46.6)
  BOTTOM w0.102: 67.84,46.56 67.85,46.55 67.84,46.56 ; 67.84,46.56 67.83,46.57 ; 67.84,46.56 67.84,46.56 ; 67.84,46.56 67.82,46.55 ; 67.84,46.56 v2(67.83,46.59) ; 67.51,46.89 67.83,46.57 ; 67.83,46.57 v2(67.83,46.59) ; 67.84,46.56 67.94,46.66 v2(67.83,46.59) ; 67.84,46.56 v2(67.83,46.59) ; v2(67.83,46.59) 67.82,46.55 ; 67.79,46.51 67.82,46.55
  BOTTOM w0.2: UNK2C19.2 67.71,46.7 v2(67.83,46.59) ; 66.7,46.89 66.57,47.01 UNK2C2.2 ; v1(58.95,6.3) 58.05,6.3 UNK1R1.2 R51.2 C63.2
  BOTTOM w0.254: 65.93,46.54 66.34,46.54 66.7,46.89 ; 65.93,46.54 v2(65.92,46.6) 65.93,46.65 65.93,46.54
  BOTTOM w0.406: 67.86,46.61 67.86,46.59 v2(67.83,46.59) 67.84,46.57
  BOTTOM w0.508: 67.82,46.58 v2(67.83,46.59) ; v2(67.83,46.59) v2(67.19,46.59) ; v2(67.83,46.59) 67.79,46.51 67.76,46.54 66.34,46.54
  BOTTOM w1.27: UNK2C4.1 62.13,46.89 67.51,46.89
VDDCPU_EN: length 97.4
  TOP w0.1: v1(60.25,51.85) 60.05,52.05 57.75,52.05 56.85,52.95 56.85,55.65 56.15,56.35 56.15,57.5 55.3,58.35 54.2,58.35 v1(53.55,59) ; v1(52,7.45) 53.05,7.45 53.6,8 53.6,13.2 52.3,14.5 52.3,16.8 53.95,18.45 v1(53.95,23.9) ; v1(43,23.7) 43,26.4 42.15,27.25 42.15,55.6 v1(41.5,56.25)
  TOP w0.102: U1.C4 v2(65.91,49.8)
  BOTTOM w0.1: v2(65.91,49.8) 65.31,50.4 64.26,50.4 UNK2R2.2 63.76,49.89 62.94,49.89 60.97,51.85 v1(60.25,51.85) ; v1(53.95,23.9) 49,23.9 48.5,23.4 43.3,23.4 v1(43,23.7) ; v1(41.5,56.25) 41.5,56.75 42,57.25 52.8,57.25 53.55,58 v1(53.55,59)
  BOTTOM w0.2: R54.1 v1(52,7.45)
VDDCPU_PWM: length 94.4
  TOP w0.1: v1(40.75,53.95) 40.95,53.75 40.95,23.65 41.65,22.95 41.65,13.9 42.95,12.6 42.95,4.85 v1(43.2,4.6)
  TOP w0.102: v2(65.26,49.15) U1.D3
  BOTTOM w0.1: v2(65.26,49.15) 65.09,49.32 62.85,49.32 62.02,50.15 60.3,50.15 56.25,54.2 54.05,54.2 52.8,55.45 43.85,55.45 42.35,53.95 v1(40.75,53.95)
  BOTTOM w0.2: v1(43.2,4.6) 43.6,4.2 56.25,4.2 56.9,4.85 R56.2 UNK1R1.1
VDDEE_PWM: length 84
  TOP w0.1: R58.2 UNK1R2.1 46.05,5.05 45.55,4.55 44.6,4.55 43.45,5.7 43.45,12.9 42.15,14.2 42.15,23.65 41.55,24.25 41.55,54.35 40.95,54.95 v1(40.75,54.95)
  TOP w0.102: v2(65.91,49.15) U1.D4
  BOTTOM w0.1: v2(65.91,49.15) 65.5,49.56 62.95,49.56 61.61,50.9 60.25,50.9 56.45,54.7 54.26,54.7 53.01,55.95 43.55,55.95 42.55,54.95 v1(40.75,54.95)
VDDIO_AO18: length 88.9
  TOP w0.254: v2(71.77,45.9) 71.96,45.7 U1.J13 72.33,45.81 v2(72.33,45.9) 72.33,45.97 U1.H13 v2(71.77,45.9) ; v2(71.77,45.9) U1.J12 ; v2(71.77,45.9) U1.H12
  TOP w0.5: v1(83.95,40.25) 84.55,40.85 84.55,45.9 85.95,47.3 v1(85.95,51.7) v1(85.95,54.1)
  MID2(L3) w0.5: v1(61.57,57.85) 62.32,57.1 69,57.1 69.8,57.9 74.58,57.9 v3(75.28,57.2) 76.43,56.05 84.3,56.05 85.95,54.4 v1(85.95,54.1)
  BOTTOM w0.1: UNK2C17.1 77.04,46.27 77.05,46.28 ; v2(71.77,45.9) 71.77,45.9 v2(72.33,45.9) ; 74.6,46.26 UNK3C1.2
  BOTTOM w0.254: 72.87,45.9 72.68,45.7 72.09,45.7 UNK5C9.2
  BOTTOM w0.3: UNK2R29.2 79.45,49.05 81.55,51.15 85.4,51.15 v1(85.95,51.7)
  BOTTOM w0.4: UNK5C9.2 71.77,45.5 v2(71.77,45.9) 72.87,45.9 72.88,45.9
  BOTTOM w0.406: 72.88,45.9 UNK2C10.2
  BOTTOM w0.5: UNK5R20.1 C76.1 U54.5 ; UNK5R20.1 v1(83.95,40.25) ; UNK5R20.1 82.25,41.26 79.6,43.91 79.6,44.91 ; v1(61.57,57.85) R106.1
  BOTTOM w0.508: 75.24,46.16 75.05,45.98 74.32,45.98 ; 75.24,46.16 76.78,46.16 ; 75.24,46.16 75.34,46.26 ; 75.34,46.26 UNK2C12.2 ; 75.34,46.26 74.6,46.26 74.32,45.98 ; 75.34,46.26 76.68,46.26 76.78,46.16 ; 74.32,45.98 72.95,45.98 UNK2C10.2 ; 76.78,46.16 UNK2C17.1 ; UNK2R3.2 75.61,53.93 75.61,56.87 v3(75.28,57.2)
  BOTTOM w0.61: 77.05,46.28 77.61,46.28 ; 77.61,46.28 77.72,46.18 78.33,46.18 ; 77.61,46.28 78.23,46.28 78.33,46.18 ; UNK2C12.2 78.45,46.56 79.6,45.42 79.6,44.91 78.33,46.18
VDDIO_BOOT: length 92.4
  TOP w0.2: v1(51.61,54.36) 51.49,54.48 UNK4R8.1 UNK4R3.1 ; v1(49.01,36.95) UNK4U9.AA5 UNK4U9.Y4 ; UNK4U9.Y4 UNK4U9.AA3 v1(48.01,36.95) ; UNK4U9.Y4 UNK4U9.W4
  TOP w0.25: UNK4U5.45 46.14,51.96 v1(45.65,52.45) ; v1(54.8,53.46) UNK4C11.2 54.64,52.59 UNK4U5.28
  TOP w0.254: v1(51.61,54.36) 51.61,53.64 UNK4C10.2 51.64,53.57 UNK4U5.34
  TOP w0.3: UNK4U9.K6 49.51,43.29 v1(49.7,43.1) ; U1.L3 65.58,44.27 v2(65.32,44.53)
  TOP w0.5: v1(43.95,51.3) v1(43.95,44.25) v1(43.95,38.95) ; v1(58.75,41.65) 58.25,41.15 v1(58.25,37.45)
  MID2(L3) w0.5: v1(50.95,35.2) 50.95,36.15 50.15,36.95 v1(49.01,36.95) 48.2,36.95 ; v1(46.2,38.95) 48.2,36.95 ; v1(46.2,38.95) 46.01,38.95 ; v1(46.2,38.95) 46.2,38.76 ; 48.2,36.95 v1(48.01,36.95) 46.2,38.76 ; v1(49.7,43.1) 49.7,43.9 49.35,44.25 43.95,44.25 v1(43.95,44.25) ; 46.01,38.95 v1(43.95,38.95) ; 46.01,38.95 46.2,38.76
  BOTTOM w0.1: UNK4C34.2 50.25,43.6 UNK4R16.1 ; UNK4R12.2 v1(46.2,38.95) ; UNK4R4.1 50.95,31.9 v1(50.95,35.2)
  BOTTOM w0.2: v1(48.01,36.95) 47.55,36.49 UNK4R14.1 UNK4R1.2 48.65,36.95
  BOTTOM w0.4: UNK4C34.2 49.8,43.2 v1(49.7,43.1) ; v1(58.75,41.65) 60.35,41.65 60.9,42.2 61.72,42.2 63.03,43.51 63.47,43.51 UNK4C2.2 64.49,44.19 64.83,44.53 v2(65.32,44.53)
  BOTTOM w0.5: v1(58.25,37.45) 57.75,36.95 UNK4R6.1 UNK4R5.1 UNK4C47.1 UNK4C35.2 v1(49.01,36.95) v1(48.01,36.95) ; v1(54.8,53.46) 53.04,53.46 52.14,54.36 v1(51.61,54.36) 50.15,54.36 49.37,53.58 46.48,53.58 45.65,52.75 v1(45.65,52.45) UNK4C48.2 44.45,51.8 v1(43.95,51.3)
VDDIO_X: length 12.4
  TOP w0.254: U1.C8 68.84,49.47 v2(69.16,49.8)
  BOTTOM w0.4: R106.2 R105.2 63.01,55.94 63.4,55.55 65.2,55.55 66.75,54 68.1,54 68.6,53.5 C102.2 68.6,50.7 69.16,50.14 v2(69.16,49.8)
VDDQ1.35V: length 76.3
  TOP w0.2: U1.M6 v2(67.86,43.29) U1.M7 68.19,43.62 v2(68.51,43.29) U1.M8 ; UNK3U1.H9 70.15,29.54 70.21,29.59 v2(70.62,29.59) ; v2(64.92,34.7) UNK3U1.B2 64.55,34.34 v2(64.15,34.74) 63.76,35.13 UNK3U1.A1 ; UNK3U1.C9 70.53,33.15 v2(70.62,33.15) 70.2,32.73 70.18,32.73 ; v2(64.92,28.31) 64.55,27.94 UNK3U1.K2 ; v2(63.19,23.83) 63.29,23.93 UNK3U1.R1 ; v2(68.91,35.54) 68.94,35.54 UNK3U1.A8 ; v1(60,6.3) 60,6.8 59.45,7.35 R61.2 C74.2 ; 70.18,32.73 v2(70.56,32.35) 70.15,31.94 UNK3U1.E9 v2(69.77,32.31) 70.15,32.69 UNK3U1.D9 70.18,32.73 ; v2(68.12,30.71) 68.17,30.71 UNK3U1.G7 68.27,30.05 v2(68.09,30.05) ; v2(68.94,27.52) UNK3U1.K8 ; UNK3U1.R9 70.16,23.94 70.68,23.94 v2(70.68,23.94) ; v2(63.15,33.53) 63.15,33.53 UNK3U1.C1 ; UNK3U1.F1 63.54,31.13 63.28,31.4 63.27,31.4 v2(63.23,31.43) ; U1.M11 v2(70.47,43.94) U1.M10 ; UNK3U1.H2 v2(64.19,29.17) ; UNK3U1.N9 70.67,25.53 v2(70.67,25.53) ; 66.89,42.97 U1.N5 v2(66.56,42.64) 66.24,42.97 U1.N4 v2(66.56,43.29) 66.89,42.97
  TOP w0.3: UNK3U1.D2 64.94,32.34 v2(64.96,32.34) ; v2(63.18,25.52) 63.74,25.52 UNK3U1.N1
  BOTTOM w0.2: v1(60,6.3) 61,7.3 61,13.15 ; 61,13.6 v1(61,13.75) ; 61,13.6 61.23,13.38 ; 61,13.6 61,13.15 ; 61,13.15 61.23,13.38 ; 61.23,13.38 v1(61.6,13.75)
  BOTTOM w0.3: UNK3C38.2 69.77,32.82 v2(69.77,32.31) 69.81,32.35 ; UNK3C38.2 70.32,32.85 v2(70.62,33.15) 70.86,33.39 ; UNK3C38.2 69.8,33.95 UNK3C42.2 70.1,33.96 ; 70.86,33.39 UNK3C58.2 70.73,33.96 70.6,33.96 ; 70.86,33.39 70.86,32.65 70.6,32.39 ; 70.1,33.96 70.3,33.96 ; 70.1,33.96 70.1,32.64 69.81,32.35 ; 69.81,32.35 70.1,32.35 ; UNK3C21.2 63.5,33.18 v2(63.15,33.53) ; 70.6,32.39 v2(70.56,32.35) 70.1,32.35 ; 70.6,32.39 70.6,33.96 ; v2(70.47,43.94) 71.04,43.37 UNK3C4.2 ; 70.1,32.35 70.3,32.55 70.3,33.96 ; 70.3,33.96 70.6,33.96
  BOTTOM w0.381: UNK3C2.2 62.92,31.74 v2(63.23,31.43)
  BOTTOM w0.4: v2(70.68,23.94) 70.42,24.21 UNK3C12.2 ; UNK3C10.2 64.92,35.18 v2(64.92,34.7) ; v2(64.96,32.34) 65.01,32.28 UNK3C11.2 ; UNK3C39.2 66.32,42.65 66.05,42.65 ; UNK3C39.2 66.63,43.36 v2(66.56,43.29) 66.56,43.16 ; UNK3C39.2 67.03,43.18 66.56,42.71 ; 66.56,42.71 66.56,43.16 ; 66.56,42.71 v2(66.56,42.64) 65.66,42.64 UNK3C62.2 ; 66.56,43.16 66.05,42.65 ; UNK3C62.2 64.85,41.85 UNK3C31.2 63.15,40.28 UNK3C28.1 ; UNK3C62.2 66.05,42.65 ; UNK3C9.2 64.15,35.12 v2(64.15,34.74) ; v2(61.44,26.9) 61.44,27.49 UNK3R19.2 61.37,27.56 v2(60.84,27.56) ; UNK3C26.1 64.92,28.7 v2(64.92,28.31) ; UNK3C18.2 63.16,25.5 v2(63.18,25.52) 63.3,25.52 UNK3C6.1 ; v2(70.62,29.59) 70.12,29.59 UNK3C45.2 ; v2(68.12,30.71) 67.66,30.71 UNK3C8.1 67.56,30.05 v2(68.09,30.05) ; UNK3C30.2 71.12,25.53 v2(70.67,25.53) ; UNK3C19.2 63.88,29.49 v2(64.19,29.17)
  BOTTOM w0.406: v2(67.86,43.29) 67.87,43.29 v2(68.51,43.29)
  BOTTOM w0.5: v1(61,14.35) v1(61.6,14.35) v1(61.6,13.75) ; v1(61,14.35) v1(61,13.75) v1(61.6,13.75) ; v1(61,14.35) v1(61.6,13.75) ; UNK3C35.2 63.19,23.42 ; 63.19,23.42 63.67,23.42 UNK3R8.2 ; 63.19,23.42 v2(63.19,23.83) ; v2(63.19,23.83) 63.31,23.83 63.72,24.24 ; v2(63.19,23.83) 63.65,23.37 UNK3R8.2 ; UNK3R8.2 63.72,24.24 ; UNK3C5.2 68.48,43.33 v2(68.51,43.29) ; 63.72,24.24 UNK3C6.1 ; UNK3C20.2 69.01,35.64 v2(68.91,35.54) ; UNK3C26.1 65.2,29.2 64.7,29.7 UNK3C19.2
  vias: v4(60.83,38.06) v4(60.85,39.07)
ACTIVE_STBY: length 123.9
  TOP w0.1: v1(44.8,25.4) 44.3,25.9 43.8,25.9 42.35,27.35 42.35,56.05 v1(42.15,56.25) ; U1.B11 71.12,50.45 71.12,50.93 70.68,51.36 70.68,54.98 71.45,55.75 71.45,58.85 v1(71.25,59.05) ; v1(67.2,16.5) 66.8,16.9 66.25,16.9 66,17.15 66,17.6 60.35,23.25 60.35,23.65 59.8,24.2 v1(59.5,24.2) ; R219.1 87.5,14.75 85.95,16.3 79.1,16.3 78.3,15.5 v1(78.14,15.5)
  BOTTOM w0.1: v1(42.15,56.25) 42.75,56.85 53,56.85 54.3,58.15 54.3,59.05 54.6,59.35 56.95,59.35 57.25,59.05 v1(71.25,59.05) ; v1(78.14,15.5) 77.74,15.9 77.04,15.9 76.64,16.3 67.4,16.3 v1(67.2,16.5) ; R320.1 44.25,25.95 v1(44.8,25.4) 44.8,24.8 45.3,24.3 47.2,24.3 48.5,25.6 57.5,25.6 58.5,24.6 59.1,24.6 v1(59.5,24.2)
AMP_RESET: length 105.2
  TOP w0.1: R215.1 v1(88.5,13.4) 88.5,14.35 86.15,16.7 78.8,16.7 78.4,16.3 v1(78.14,16.3) ; v1(67.2,17.3) 66.8,17.7 66.47,17.7 60.75,23.42 60.75,23.85 59.6,25 v1(59.5,25) ; v1(47.15,26) 46.8,26.35 43.95,26.35 42.75,27.55 42.75,56.9 42.2,57.45 42.2,60.05 v1(42.35,60.2)
  BOTTOM w0.1: UNK5R74.2 v1(88.5,13.4) ; v1(78.14,16.3) 77.74,16.7 67.85,16.7 67.25,17.3 v1(67.2,17.3) ; 48.58,67.12 48.1,66.65 42.8,66.65 40.05,63.9 40.05,60.25 40.35,59.95 42.1,59.95 v1(42.35,60.2) ; v1(59.5,25) 58.5,26 v1(47.15,26) R315.1
  BOTTOM w0.3: T317.1 48.58,67.12
AMP_SCL: length 67.9
  TOP w0.1: UNK2R24.2 v1(81.5,59.05) ; v1(87.8,59) 87.8,54.25 88.2,53.85 88.2,32.9 89.4,31.7 89.4,20.1 v1(89.6,19.9)
  TOP w0.102: v1(81.5,59.05) 81.9,58.65 81.9,57.8 81.24,57.14 78.36,57.14 75.8,54.57 75.8,53.46 74.04,51.69 U1.A16
  BOTTOM w0.1: v1(89.6,19.9) 89.4,19.7 88.15,19.7 86.7,18.25 86.7,16.3 87.4,15.6 UNK5R66.2 ; v1(87.8,59) 87.6,58.8 86.45,58.8 85.65,59.6 82.85,59.6 R209.1 v1(81.5,59.05)
AMP_SCL_DEV: length 66.1
  TOP w0.1: v1(83.75,59.05) 83.95,59.25 83.95,61.15 v1(83.8,61.3) ; v1(43.3,60.9) 43.05,60.65 43.05,59.45 v1(42.65,59.05) ; v1(52.3,58.45) 52.3,58.25 52.85,57.7 R309.1
  BOTTOM w0.1: v1(52.3,58.45) 51.9,58.05 44.65,58.05 44.2,58.5 43.65,58.5 43.5,58.65 43.05,58.65 v1(42.65,59.05) ; R209.2 v1(83.75,59.05) R238.1 ; 77.7,67.85 78.05,67.85 79.1,66.8 79.1,64.1 81.7,61.5 83.6,61.5 v1(83.8,61.3) ; v1(43.3,60.9) 43.7,61.3 43.7,63.85 44.1,64.25 52.6,64.25 53.15,64.8 68.15,64.8 69.15,65.8 69.7,65.8 70.6,66.7 74.55,66.7 75.7,67.85 76.1,67.85
  BOTTOM w0.3: 77.7,67.85 T306.1 76.1,67.85
AMP_SDA: length 70.2
  TOP w0.1: v1(81.5,57.95) UNK2R28.2 80.25,57.35 78.27,57.35 ; v1(90.25,19.9) 89.6,20.55 89.6,31.87 88.4,33.07 88.4,53.95 88.01,54.34 88.01,57.61 v1(88.4,58)
  TOP w0.102: 78.27,57.35 75.59,54.66 75.59,53.55 73.71,51.67 73.71,50.59 73.39,50.27 U1.B15
  BOTTOM w0.1: UNK5R65.2 87.4,13.3 87.95,13.85 87.95,15.35 86.9,16.4 86.9,18.15 88.25,19.5 89.85,19.5 v1(90.25,19.9) ; v1(81.5,57.95) R210.1 82.85,57.4 85.7,57.4 86.5,58.2 88.2,58.2 v1(88.4,58)
AMP_SDA_DEV: length 69.4
  TOP w0.1: v1(51.7,58.45) 51.7,58.25 52.5,57.45 52.5,57.1 R310.1 ; v1(43.25,59.05) 43.25,60.25 43.7,60.7 43.7,61.1 v1(43.3,61.5) ; v1(83.75,57.95) 84.15,58.35 84.15,61 v1(84.45,61.3)
  BOTTOM w0.1: v1(84.45,61.3) 84.05,61.7 81.8,61.7 79.3,64.2 79.3,67.2 ; v1(43.25,59.05) 43.4,59.05 43.75,58.7 44.35,58.7 44.8,58.25 51.5,58.25 v1(51.7,58.45) ; 78.72,68.42 78.5,68.65 76.2,68.65 74.45,66.9 70.5,66.9 69.6,66 69.05,66 68.05,65 53.05,65 52.5,64.45 43.95,64.45 43.5,64 43.5,61.7 v1(43.3,61.5) ; R239.1 v1(83.75,57.95) R210.2
  BOTTOM w0.3: 79.3,67.2 T305.1 78.72,68.42
BCLK: length 5.7
  BOTTOM w0.102: UNK5R68.1 85,10.75 86.15,9.6 87.8,9.6 88.68,8.72 J813.11
CPU_RESET: length 126.6
  TOP w0.1: v1(72.05,59.65) 72.05,59.35 71.85,59.15 71.85,57.61 UNK2U2.2 72.24,56.64 UNK2R14.1 72.23,55.47 71.39,54.63 71.39,51.83 71.13,51.56 71.13,51.25 71.44,50.94 U1.A12 ; v1(44.05,58.05) 44.05,57.65 43.35,56.95 43.35,36.8 43.8,36.35 43.8,34.35 43.15,33.7 43.15,27.6 44.1,26.65 46.75,26.65 v1(47.15,27.05) ; R240.1 90.4,15.25 88.2,15.25 86.35,17.1 v1(78.15,17.1) ; v1(59.5,25.7) 60.95,24.25 60.95,23.52 66.57,17.9 67.4,17.9 v1(68,17.3)
  BOTTOM w0.1: R338.1 47.1,27.1 v1(47.15,27.05) 48,26.2 59,26.2 v1(59.5,25.7) ; v1(68,17.3) 68.4,16.9 77.95,16.9 v1(78.15,17.1) ; v1(72.05,59.65) 71.65,60.05 70.5,60.05 70.1,59.65 67.55,59.65 66.95,60.25 65.8,60.25 65.4,59.85 57.7,59.85 57.4,60.15 54.15,60.15 53.85,59.85 53.2,59.85 52.75,59.4 52.75,58.15 52.45,57.85 44.25,57.85 v1(44.05,58.05)
CTRL_A113X: length 2.8
  BOTTOM w0.1: UNK5R76.1 UNK5R77.1 UNK5R75.2
DATA: length 8.3
  BOTTOM w0.102: UNK5R69.1 84.5,13.7 84.5,10.65 85.85,9.3 87.6,9.3 88.18,8.72 J813.12
DDR3_A0: length 28.5
  TOP w0.102: v2(71.12,41.34) U1.R12 ; v2(67.05,24.73) 66.58,24.73 65.78,25.53 UNK3U1.N3
  BOTTOM w0.102: v2(71.12,41.34) 71.12,41.21 70.76,40.86 70.76,40.62 71.04,40.34 71.29,40.34 72.41,39.22 73.17,39.22 75.04,37.35 75.04,26.89 73.05,24.89 72.26,24.89 72.03,25.12 70.35,25.12 70.23,25 67.32,25 v2(67.05,24.73)
DDR3_A1: length 24.7
  TOP w0.1: v2(68.94,24.35) 68.56,24.73 UNK3U1.P7
  TOP w0.102: v2(72.4,23.64) 72.6,23.64 75.62,26.66 75.62,37.51 73.45,39.68 73.45,40.31 U1.U15
  BOTTOM w0.102: v2(72.4,23.64) 72.4,23.43 71.7,22.74 69.85,22.74 69.31,23.27 69.31,23.98 v2(68.94,24.35)
DDR3_A2: length 34.8
  TOP w0.102: v2(74.37,41.99) U1.P16 ; v2(66.15,23.76) 66.15,24.3 65.72,24.73 UNK3U1.P3
  BOTTOM w0.102: v2(66.15,23.76) 66.71,23.76 69.59,20.88 72.92,20.88 77.8,25.76 77.8,38.84 75.81,40.82 75.26,40.82 74.77,41.3 74.77,41.59 v2(74.37,41.99)
DDR3_A3: length 35.7
  TOP w0.102: U1.U17 76.93,38.13 76.93,26.11 71.98,21.16 65.91,21.16 64.86,22.21 64.1,22.21 62.84,23.47 62.84,24.98 63,25.15 63.89,25.15 64.27,25.53 UNK3U1.N2
DDR3_A4: length 24.6
  TOP w0.102: U1.R11 70.79,41.69 v2(71.04,41.94) ; v2(71.85,25.53) 71.45,25.12 69.74,25.12 UNK3U1.P8
  BOTTOM w0.102: v2(71.85,25.53) 72.04,25.53 72.4,25.17 72.92,25.17 74.75,27 74.75,37.29 73.05,38.98 72.29,38.98 71.15,40.12 70.9,40.12 70.47,40.55 70.47,40.93 70.76,41.23 70.76,41.66 v2(71.04,41.94)
DDR3_A5: length 30.3
  TOP w0.102: U1.T14 72.67,40.94 72.67,40.77 72.44,40.54 72.44,40.23 72.61,40.06 72.79,40.06 72.94,39.91 72.94,39.45 75.04,37.35 75.04,26.89 72.77,24.61 72.36,24.61 71.65,23.9 71.65,23.12 71.27,22.74 66.59,22.74 66.37,22.96 66.37,23.4 66.53,23.56 66.53,24.35 65.74,25.14 65.12,25.14 64.72,24.73 UNK3U1.P2
DDR3_A6: length 24.4
  TOP w0.102: UNK3U1.R8 69.76,24.34 71.55,24.34 v2(71.89,24.68) ; v2(71.77,41.99) U1.P12
  BOTTOM w0.102: v2(71.89,24.68) 71.95,24.61 73.17,24.61 75.33,26.77 75.33,37.42 71.77,40.98 v2(71.77,41.99)
DDR3_A7: length 29.3
  TOP w0.102: U1.U14 72.74,40.35 72.9,40.35 73.2,40.06 73.2,39.55 75.33,37.42 75.33,26.77 72.89,24.34 72.49,24.34 71.95,23.8 71.95,22.99 71.42,22.46 66.49,22.46 65.74,23.21 65.74,24.16 65.58,24.32 64.94,24.32 UNK3U1.R2
DDR3_A8: length 25.1
  TOP w0.102: v2(71.27,23.93) 70.89,23.55 69.77,23.55 UNK3U1.T8 ; U1.P13 72.35,42.06 v2(72.35,42.04)
  BOTTOM w0.102: v2(71.27,23.93) 71.52,23.93 71.9,24.31 73.27,24.31 75.62,26.66 75.62,37.51 72.06,41.07 72.06,41.74 v2(72.35,42.04)
DDR3_A9: length 31.6
  TOP w0.102: UNK3U1.R3 64.97,23.55 64.97,22.91 65.12,22.76 65.12,22.35 66.04,21.44 71.88,21.44 76.63,26.19 76.63,38.03 74.65,40.01 74.57,40.01 74.37,40.21 74.37,40.69 U1.T16
DDR3_A10: length 22.8
  TOP w0.102: UNK3U1.L7 68.93,26.75 73.22,26.75 v2(73.5,27.03) ; U1.R10 70.14,41.67 70.39,41.42 v2(70.4,41.42)
  BOTTOM w0.102: v2(70.4,41.42) 70.16,41.18 70.16,40.49 70.8,39.85 71.06,39.85 72.2,38.72 72.91,38.72 74.44,37.19 74.44,27.97 v2(73.5,27.03)
DDR3_A11: length 35.3
  TOP w0.102: v2(66.75,23.14) 66.85,23.04 67.92,23.04 68.55,23.67 UNK3U1.R7 ; v2(75.03,41.99) 74.7,42.32 U1.P17
  BOTTOM w0.102: v2(66.75,23.14) 66.95,23.14 69.49,20.6 73.05,20.6 78.08,25.63 78.08,38.97 75.94,41.1 75.38,41.1 75.06,41.42 75.06,41.97 75.04,41.99 v2(75.03,41.99)
DDR3_A12: length 30.8
  TOP w0.102: v2(67.92,23.62) 67.91,23.63 68.17,23.89 68.17,25.15 UNK3U1.N7 ; U1.T17 74.69,41.02 75.08,41.02 75.54,40.57 v2(75.54,40.08)
  BOTTOM w0.102: v2(75.54,40.08) 77.24,38.38 77.24,26.01 72.67,21.44 69.82,21.44 67.92,23.34 v2(67.92,23.62)
DDR3_A13: length 29
  TOP w0.102: U1.R15 73.37,41.65 73.71,41.31 73.71,39.8 75.92,37.59 75.92,26.52 71.57,22.18 66.39,22.18 65.44,23.13 UNK3U1.T3
DDR3_A14: length 27.6
  TOP w0.1: UNK3U1.T7 68.55,23.14 v2(68.92,23.51)
  TOP w0.102: v2(73.01,41.42) 72.99,41.42 U1.R14
  BOTTOM w0.102: v2(68.92,23.51) 68.92,23.24 69.71,22.46 72.89,22.46 76.63,26.19 76.63,38.03 73.24,41.42 v2(73.01,41.42)
DDR3_A15: length 29.2
  TOP w0.102: v2(67.79,24.54) 67.79,25.57 UNK3U1.M7 ; U1.T13 72.09,41.02 v2(72.42,41.34)
  BOTTOM w0.102: v2(72.42,41.34) 72.71,41.05 73.22,41.05 74.14,40.13 74.14,39.41 75.92,37.63 75.92,26.52 73.43,24.03 72.08,24.03 71.62,23.57 70.53,23.57 70.4,23.7 69.82,23.7 69.64,23.88 69.64,24.23 69.16,24.72 67.97,24.72 v2(67.79,24.54)
DDR3_BA0: length 41
  TOP w0.102: U1.N16 74.06,42.97 74.25,42.78 74.81,42.78 75.97,41.62 75.97,39.66 77.24,38.39 77.24,26.01 72.11,20.88 65.78,20.88 64.71,21.95 63.95,21.95 62.53,23.37 62.53,25.49 62.97,25.94 64.16,25.94 UNK3U1.M2
DDR3_BA1: length 20.5
  TOP w0.102: U1.U12 71.44,40.01 71.62,39.83 71.62,39.65 72.28,38.99 72.64,38.99 74.44,37.19 74.44,27.1 73.27,25.94 69.76,25.94 UNK3U1.N8
DDR3_BA2: length 45
  TOP w0.102: UNK3U1.M3 64.94,26.74 63.05,26.74 62.23,25.91 62.23,23.37 65.27,20.32 72.36,20.32 77.8,25.76 77.8,38.84 76.5,40.13 76.5,41.76 74.98,43.28 74.51,43.28 74.17,43.62 U1.M16
DDR3_CAS: length 35.4
  TOP w0.102: U1.P15 73.39,42.32 v2(73.07,41.99) ; v2(67.41,23.98) 67.41,26.85 66.32,27.93 UNK3U1.K3
  BOTTOM w0.102: v2(73.07,41.99) 76.93,38.13 76.93,26.11 73,22.18 69.56,22.18 68.42,23.31 68.42,23.62 68.06,23.98 v2(67.41,23.98)
DDR3_CKE0: length 19
  TOP w0.102: v2(73.05,28.17) 72.44,28.17 72.2,27.94 70.16,27.94 UNK3U1.K9 ; U1.P10 70.14,42.32 v2(69.82,41.99)
  BOTTOM w0.102: v2(73.05,28.17) 73,28.22 73,36.34 69.4,39.93 69.4,41.59 69.8,41.99 v2(69.82,41.99)
DDR3_CLKN: length 20.6
  TOP w0.102: v2(67.8,28.04) 67.83,28.07 67.95,28.2 68.46,28.2 68.55,28.1 UNK3U1.K7 ; U1.T10 70.13,41.01 70.13,40.91 69.82,40.6 69.82,39.73 70.15,39.4 70.15,39.39 70.16,39.37 70.16,38.9 70.64,38.43 UNK3C7.1 71.07,38.1 72.92,36.25 72.92,29.67 v2(71.83,28.58)
  BOTTOM w0.102: v2(71.83,28.58) 71.83,28.56 71.69,28.43 68.3,28.43 67.95,28.08 67.92,28.08 v2(67.8,28.04) 67.79,28.05 67.79,28.06 67.65,28.21 67.44,28.21 UNK3R2.2
DDR3_CLKP: length 19.4
  TOP w0.102: U1.U9 69.54,40.32 69.54,39.6 69.88,39.26 69.88,38.79 70.35,38.32 UNK3C7.2 71.06,37.71 72.64,36.13 72.64,29.8 72.12,29.28 71.92,29.28 v2(71.9,29.26) ; v2(67.76,28.68) 67.81,28.64 67.98,28.48 68.47,28.48 68.55,28.55 UNK3U1.J7
  BOTTOM w0.1: v2(67.76,28.68) 67.59,28.68 UNK3R2.1
  BOTTOM w0.102: v2(71.9,29.26) 71.34,28.7 67.88,28.7 67.82,28.64 v2(67.76,28.68)
DDR3_DQ0: length 7.1
  TOP w0.1: UNK3U1.A2 63.62,36.06 63.62,36.06
  TOP w0.102: 63.62,36.06 63.62,40.16 64.16,40.69 64.45,40.69 64.78,41.02 64.94,41.02 U1.T2
DDR3_DQ1: length 9.9
  TOP w0.102: UNK3U1.C2 64.77,33.53 65.17,33.13 65.48,33.13 66.01,33.66 66.01,35.73 64.94,36.79 64.94,39.46 65.27,39.79 65.27,40.57 65.58,40.87 65.58,41.01 U1.T3
DDR3_DQ2: length 8.3
  TOP w0.102: UNK3U1.A7 68.32,35.36 68.32,35.88 v2(68.42,35.98) ; v2(67.21,41.99) U1.P6
  BOTTOM w0.102: v2(68.42,35.98) 68.4,36 68.3,36 67.31,37 67.31,40.69 67.64,41.02 67.64,41.57 67.21,41.99 v2(67.21,41.99)
DDR3_DQ3: length 10.3
  TOP w0.102: U1.U7 68.35,40.24 68.35,37.09 69.54,35.89 70.19,35.89 70.51,35.58 70.51,34.15 70.29,33.94 69.95,33.94 69.76,33.74 69.76,33.37 69.53,33.14 69.05,33.14 68.64,32.73 UNK3U1.D7
DDR3_DQ4: length 6.1
  TOP w0.102: UNK3U1.A3 64.89,35.59 64.63,35.59 63.93,36.29 63.93,40.01 U1.U1
DDR3_DQ5: length 7.6
  TOP w0.102: UNK3U1.C3 65.36,33.53 65.71,33.88 65.71,35.58 64.64,36.64 64.64,39.59 64.94,39.89 U1.U2
DDR3_DQ6: length 8.5
  TOP w0.102: U1.R6 67.54,41.66 v2(67.28,41.4) ; UNK3U1.B8 v2(68.94,34.74)
  BOTTOM w0.102: v2(68.94,34.74) 68.94,34.9 67,36.85 67,40.77 67.28,41.05 v2(67.28,41.4)
DDR3_DQ7: length 8.6
  TOP w0.102: UNK3U1.C8 69.35,33.81 69.74,34.21 69.74,35.26 68.04,36.96 68.04,40.05 67.86,40.22 67.86,40.55 68.19,40.87 U1.T7
DDR3_DQ8: length 15.3
  TOP w0.102: U1.T8 68.75,40.93 68.75,39.3 69.06,38.99 69.06,37.42 69.87,36.6 70.51,36.6 71.5,35.61 71.5,30.67 70.8,29.97 69.24,29.97 68.79,29.53 UNK3U1.H7
DDR3_DQ9: length 13.7
  TOP w0.102: U1.R2 64.93,41.69 64.75,41.69 64.4,41.34 63.98,41.34 62.91,40.27 62.91,36.58 62.12,35.79 62.12,32.49 62.78,31.83 63.34,31.83 63.65,31.52 64.16,31.52 UNK3U1.F2
DDR3_DQ10: length 16.2
  TOP w0.102: U1.R9 69.16,41.34 69.16,40.86 68.98,40.68 68.98,39.38 69.36,39 69.36,37.56 70.04,36.88 70.68,36.88 71.8,35.77 71.8,30.52 70.99,29.71 70.99,29.46 70.7,29.17 69.71,29.17 UNK3U1.H8
DDR3_DQ11: length 11
  TOP w0.1: UNK3U1.E3 65.35,31.96 v2(65.65,32.26)
  TOP w0.102: v2(65.91,41.34) U1.R4
  BOTTOM w0.102: v2(65.91,41.34) 65.73,41.16 65.73,36.68 66.54,35.87 66.54,34.4 65.39,33.25 65.39,32.52 v2(65.65,32.26)
DDR3_DQ12: length 14.9
  TOP w0.102: UNK3U1.F8 69.72,31.5 v2(69.72,31.52) ; v2(68.49,41.96) U1.R7
  BOTTOM w0.102: v2(69.72,31.52) 71.04,31.52 71.8,32.29 71.8,35.76 70.65,36.91 70.07,36.91 68.35,38.64 68.35,41.1 68.25,41.2 68.25,41.59 v2(68.49,41.96)
DDR3_DQ13: length 17.4
  TOP w0.102: UNK3U1.H3 65.18,29.53 64.79,29.92 63.15,29.92 61.11,31.97 61.11,36.27 61.9,37.06 61.9,40.69 63.52,42.32 64.29,42.32 U1.P1
DDR3_DQ14: length 17
  TOP w0.102: v2(68.96,30.74) 68.56,31.13 UNK3U1.F7 ; v2(69.21,42.04) 69.47,42.3 U1.P9
  BOTTOM w0.102: v2(69.21,42.04) 69.08,41.91 69.08,39.59 72.54,36.13 72.54,31.89 71.38,30.73 70.39,30.73 70,30.34 69.35,30.34 v2(68.96,30.74)
DDR3_DQ15: length 14.2
  TOP w0.102: UNK3U1.G2 64.14,30.74 63.41,30.74 61.82,32.32 61.82,35.92 62.61,36.71 62.61,40.39 63.9,41.68 64.28,41.68 U1.R1
DDR3_DQM0: length 10.4
  TOP w0.102: v2(65.86,32.96) 65.63,32.73 UNK3U1.D3 ; v2(66.56,41.34) U1.R5
  BOTTOM w0.102: v2(65.86,32.96) 65.86,33.17 66.87,34.19 66.87,36.05 66.06,36.86 66.06,40.84 v2(66.56,41.34)
DDR3_DQM1: length 15.8
  TOP w0.1: v2(68.07,31.93) UNK3U1.E7
  TOP w0.102: U1.P7 68.17,42.32 v2(67.93,42.08)
  BOTTOM w0.102: v2(67.93,42.08) 67.93,41.89 68.04,41.77 68.04,38.48 69.95,36.58 70.51,36.58 71.43,35.66 71.43,32.44 70.93,31.93 v2(68.07,31.93)
DDR3_DQSN0: length 7.9
  TOP w0.102: U1.T6 67.23,40.7 67.23,37.01 67.71,36.53 67.71,34.56 68.19,34.09 68.31,34.09 UNK3U1.B7
DDR3_DQSN1: length 13.3
  TOP w0.102: UNK3U1.G3 65.59,30.33 65.72,30.46 arc(65.75,30.53) 65.72,30.59 65.61,30.71 arc(65.58,30.77) 65.61,30.84 65.69,30.92 arc(65.75,30.95) 65.81,30.92 65.93,30.8 arc(66,30.77) 66.06,30.8 66.15,30.89 arc(66.18,30.95) 66.15,31.02 66.04,31.13 arc(66.01,31.19) 66.04,31.26 66.11,31.33 arc(66.18,31.36) 66.24,31.33 66.35,31.22 arc(66.42,31.19) 66.48,31.22 66.54,31.28 66.54,31.55 arc(66.52,31.61) 66.45,31.64 66.39,31.64 arc(66.33,31.66) 66.3,31.73 66.3,31.84 arc(66.33,31.9) 66.39,31.93 66.45,31.93 arc(66.52,31.96) 66.54,32.02 66.54,35.98 65.76,36.77 65.76,39.32 65.98,39.55 65.98,40.13 65.91,40.21 65.91,40.69 U1.T4
DDR3_DQSP0: length 7.6
  TOP w0.102: U1.U5 66.95,40.31 66.95,36.9 67.43,36.41 67.43,34.46 68.07,33.82 68.26,33.82 68.55,33.54 UNK3U1.C7
DDR3_DQSP1: length 13.3
  TOP w0.102: UNK3U1.F3 65.27,31.13 64.97,30.83 64.97,30.14 65.17,29.94 65.6,29.94 66.82,31.16 66.82,36.1 66.04,36.88 66.04,39.19 66.26,39.42 66.26,40.37 U1.U4
DDR3_NCS0: length 23.4
  TOP w0.102: UNK3U1.L2 64.97,27.55 66.2,27.55 v2(66.4,27.35) ; v2(72.54,27.71) 73.25,27.71 73.73,28.2 73.73,36.86 71.22,39.37 71.22,39.63 70.86,39.98 70.86,40.29 70.79,40.36 U1.U11
  BOTTOM w0.102: v2(66.4,27.35) 66.48,27.27 68.13,27.27 68.75,27.89 72.36,27.89 v2(72.54,27.71)
DDR3_ODT0: length 37.6
  TOP w0.1: v2(63.15,27.33) UNK3U1.K1
  TOP w0.102: U1.R16 74.34,41.37 v2(74.34,41.37)
  BOTTOM w0.102: v2(63.15,27.33) 63.69,26.8 64.74,26.8 65.5,26.04 65.5,25.35 69.69,21.16 72.79,21.16 77.52,25.89 77.52,38.64 75.63,40.52 75.19,40.52 v2(74.34,41.37)
DDR3_RAS: length 24.7
  TOP w0.102: UNK3U1.J3 66.25,28.73 68.12,26.86 v2(68.12,26.7) ; U1.T11 70.81,41 70.74,40.92 70.74,40.82 70.48,40.57 70.48,40.16 70.58,40.06 70.58,39.88 70.84,39.63 v2(70.84,39.42)
  BOTTOM w0.102: v2(68.12,26.7) 72.59,26.7 73.73,27.84 73.73,36.86 71.17,39.42 v2(70.84,39.42)
DDR3_RST: length 37.9
  TOP w0.1: v2(64.71,22.57) 64.55,22.74 UNK3U1.T2
  TOP w0.102: v2(64.74,21.39) 65.53,20.6 72.23,20.6 77.52,25.89 77.52,38.64 76.22,39.93 76.22,41.68 74.87,43.03 74.43,43.03 74.17,43.29 73.72,43.29 U1.M15
  BOTTOM w0.1: UNK3R8.1 64.74,22.59 v2(64.71,22.57) 64.69,22.54 UNK3C46.2 64.69,21.44 v2(64.74,21.39)
DDR3_WE: length 28
  TOP w0.102: U1.R13 71.78,41.36 71.78,40.08 71.89,39.97 71.89,39.76 72.4,39.25 72.78,39.25 74.75,37.28 74.75,27 73.3,25.55 v2(72.64,25.55) ; UNK3U1.L3 65.67,27.13 66.7,26.1 v2(66.7,25.28)
  BOTTOM w0.102: v2(72.64,25.55) 72.16,26.04 70.85,26.04 70.75,25.94 70.3,25.94 69.64,25.28 v2(66.7,25.28)
EMMC_1.8V: length 3.1
  BOTTOM w0.5: UNK4R5.2 C77.1 53.65,34.6 U55.5
GPIOX_16: length 7.5
  TOP w0.102: U1.D10 70.14,48.82 v2(69.82,49.15)
  BOTTOM w0.1: v2(69.82,49.15) 69.88,49.21 69.88,50.27 70.05,50.43 70.05,51.5 68.98,52.57 68.98,55.14 T125.1
GPIOX_17: length 5.1
  TOP w0.102: v2(68.51,49.15) U1.D8
  BOTTOM w0.1: T126.1 68.12,52.88 68.12,50.68 68.8,49.99 68.8,49.44 v2(68.51,49.15)
GPIOX_18: length 3.5
  TOP w0.102: v2(70.47,49.8) U1.C10
  BOTTOM w0.1: T127.1 70.45,52.03 70.79,51.69 70.79,50.12 v2(70.47,49.8)
GPIOZ_10: length 4.6
  TOP w0.1: U1.E2 64.85,48.26 64.11,48.26 62.48,49.89 62.48,50.5 62.38,50.6 UNK2T3.1
HW_VS: length 5
  TOP w0.102: v2(73.72,49.15) U1.D15
  BOTTOM w0.1: v2(73.72,49.15) 74.52,49.95 75.27,50.7 75.9,50.7 UNK2R15.2 76.3,52.22 UNK2R3.1
I2SIN_BCLK_C: length 49.8
  TOP w0.1: v1(87,20.95) 87,21.55 87.55,22.1 87.55,30.92 86.4,32.07 v1(86.4,44.35)
  TOP w0.102: U1.G15 73.39,46.87 v2(73.66,47.13)
  BOTTOM w0.1: v2(73.66,47.13) 73.82,47.13 74.7,48.01 78.67,48.01 83.33,43.35 85.4,43.35 v1(86.4,44.35) ; v1(87,20.95) 85.65,19.6 85.65,15.55 85.85,15.35 85.85,13.35 85,12.5 UNK5R68.2
I2SIN_DATA_C: length 41.2
  TOP w0.1: v1(87.3,50.3) 86.85,49.85 86.85,46.9 87.2,46.55 87.2,32.45 88.4,31.25 88.4,21.75 v1(87.95,21.3)
  BOTTOM w0.1: v1(87.95,21.3) 87.62,21.62 86.62,21.62 85.1,20.1 85.1,15.1 UNK5R69.2 ; v1(87.3,50.3) R104.2 R103.2
I2SIN_LRCK_C: length 50.3
  TOP w0.1: v1(83.85,47.6) 83.4,48.05 80.4,48.05 80.05,47.7 75.15,47.7 74.97,47.52 U1.F17 ; v1(87.25,47.15) 87.4,47 87.4,32.53 88.6,31.33 88.6,20.6 v1(88.45,20.45)
  BOTTOM w0.1: UNK5R67.2 86.2,12.15 86.5,12.45 86.5,13.4 86.35,13.55 86.35,15.7 86.2,15.85 86.2,18.65 87.8,20.25 88.25,20.25 v1(88.45,20.45) ; v1(83.85,47.6) 84.2,47.25 87.15,47.25 v1(87.25,47.15)
I2SIN_MCLK_B: length 40.3
  TOP w0.1: v1(86.4,46.15) 85.6,45.35 85.6,31.7 86.75,30.55 86.75,22.85 v1(86.45,22.55) ; R102.2 v1(83.1,46.2)
  BOTTOM w0.1: UNK5R70.2 83.65,15.6 84.5,16.45 84.5,20.6 v1(86.45,22.55) ; v1(86.4,46.15) 86,46.55 83.45,46.55 v1(83.1,46.2)
I2SO_BCLK: length 136.5
  TOP w0.1: v1(91.35,60.4) 90.8,59.85 90.8,56.9 91.45,56.25 v1(91.45,47) v1(91.45,45.4) 91.65,45.2 91.65,38.55 90.75,37.65 90.75,25.95 v1(91.65,25.05) ; R107.2 v1(83.2,45.1) ; v1(41.6,62.45) 40.15,62.45 38.35,60.65 v1(38.35,60.1) 38.35,58.75 38.7,58.4 38.7,52.55 38.5,52.35 38.5,50.6 39.15,49.95 39.15,38.9 v1(38.4,38.15)
  BOTTOM w0.1: v1(91.35,60.4) 91.35,61 91.15,61.2 86.5,61.2 84.95,62.75 82.3,62.75 80.9,64.15 80.9,68.5 79.4,70 73.3,70 71.9,68.6 70.05,68.6 69.88,68.42 ; v1(83.2,45.1) 84.1,45.1 C103.2 85.05,45.05 85.3,45.3 91.35,45.3 v1(91.45,45.4) ; 68.67,67.22 67.45,66 52.55,66 52,65.45 43.4,65.45 41.6,63.65 v1(41.6,62.45) ; R327.1 v1(38.35,60.1)
  BOTTOM w0.2: R227.1 v1(91.45,47) ; v1(38.4,38.15) R325.1 ; R229.1 v1(91.65,25.05)
  BOTTOM w0.3: 68.67,67.22 T309.1 69.88,68.42
I2SO_DATA0: length 125.9
  TOP w0.1: v1(89.85,62.2) 89.6,61.95 89.6,55.64 v1(89.9,55.34) 89.6,55.04 89.6,49.45 v1(89.85,49.2) ; v1(41.05,61.25) 40.85,61.05 40.85,59.8 39.55,58.5 39.55,52.05 39.75,51.85 39.75,30 v1(39.55,29.8)
  BOTTOM w0.1: 83.95,48.1 83.6,48.1 83.2,47.7 C105.2 81.45,47.7 R109.2 ; 83.95,48.1 90,48.1 90.3,48.4 90.3,48.8 89.9,49.2 v1(89.85,49.2) ; 83.95,48.1 R231.2 ; v1(41.05,61.25) 40.5,61.8 40.5,63.75 43,66.25 51.6,66.25 52.15,66.8 64.75,66.8 67.65,69.7 71.4,69.7 72.8,71.1 80,71.1 82.05,69.05 82.05,64.65 82.45,64.25 87.9,64.25 88.4,63.75 R225.2 88.95,63.7 89.85,62.8 v1(89.85,62.2)
  BOTTOM w0.2: U201.7 93.39,54.8 93.2,54.99 91.5,54.99 91.15,55.34 v1(89.9,55.34) ; U301.7 36.66,30.34 36.85,30.15 38.55,30.15 38.9,29.8 v1(39.55,29.8)
I2SO_DATA1: length 120.9
  TOP w0.1: v1(89.25,62.2) 89.4,62.05 89.4,48.95 v1(89.85,48.5) 89.45,48.1 89.45,33.85 v1(89.9,33.4) ; v1(39.3,51.75) 39.3,58.55 40.45,59.7 v1(40.45,60.45)
  BOTTOM w0.1: R110.2 C106.2 83.15,48.75 83.5,49.1 R231.1 83.9,49.1 84.7,48.3 89.65,48.3 v1(89.85,48.5) ; R226.2 88.8,62.2 v1(89.25,62.2) 89.65,61.8 90.05,61.8 90.25,62 90.25,62.7 88.5,64.45 82.55,64.45 82.25,64.75 82.25,69.2 80.15,71.3 72.72,71.3 71.32,69.9 67.57,69.9 64.67,67 52.05,67 51.5,66.45 42.9,66.45 40.3,63.85 40.3,60.6 v1(40.45,60.45)
  BOTTOM w0.2: U202.7 93.39,32.86 93.2,33.05 91.5,33.05 91.15,33.4 v1(89.9,33.4) ; v1(39.3,51.75) 38.9,51.75 38.55,52.1 36.85,52.1 36.66,52.29 U302.7
I2SO_LRCLK: length 136.4
  TOP w0.1: v1(39.95,27.25) 39.95,49 v1(40.15,49.2) 39.95,49.4 39.95,51.95 39.75,52.15 39.75,58.4 41.05,59.7 41.05,60.7 v1(42.85,62.5) ; v1(84.75,47.65) 84.3,47.2 83.65,47.2 83.05,47.8 81.4,47.8 80.85,47.25 78.85,47.25 78.5,46.9 C104.2 R108.2 ; v1(89.85,35.95) 89.65,36.15 89.65,47.45 v1(89.85,47.65) 90.25,48.05 90.25,49.35 89.8,49.8 89.8,54.65 90.3,55.15 90.3,55.5 89.8,56 89.8,57.75 v1(90,57.95) 90,60.25 v1(90.15,60.4)
  BOTTOM w0.1: 74.88,68.42 75.55,69.1 79.05,69.1 80,68.15 80,63.8 81.9,61.9 84.6,61.9 85.9,60.6 89.95,60.6 v1(90.15,60.4) ; v1(84.75,47.65) 84.95,47.85 89.65,47.85 v1(89.85,47.65) ; v1(42.85,62.5) 43.3,62.95 43.3,64.1 43.85,64.65 52.4,64.65 52.95,65.2 67.95,65.2 68.95,66.2 69.5,66.2 70.4,67.1 74.3,67.1 74.3,67.2
  BOTTOM w0.2: v1(89.85,35.95) 90.1,35.7 R230.1 ; v1(90,57.95) 90.1,57.85 R228.1 ; v1(40.15,49.2) 40.15,49.25 39.95,49.45 R328.1 ; R326.1 v1(39.95,27.25)
  BOTTOM w0.3: 74.3,67.2 T307.1 74.88,68.42
I2SO_MCLK_A: length 1.1
  TOP w0.1: T101.1 R101.2
IR_IN: length 4.6
  TOP w0.1: UNK2T6.1 73.16,52.23
  TOP w0.102: U1.B14 73.07,50.44 73.07,51.08 73.16,51.17 73.16,52.23
IR_OUT: length 10.5
  TOP w0.102: U1.B13 72.1,50.34 72.44,50.68 72.44,53.11 76.71,57.39 UNK2T5.1
LCD_BL_EN: length 26.4
  TOP w0.1: U1.B1 64.11,50.12 63.72,50.52 63.72,51.09 62.28,52.53 62.28,53.34 61.5,54.12 61.5,57.3 61.19,57.61 61.19,63.41 v1(60.9,63.7)
  BOTTOM w0.1: v1(60.9,63.7) 60.5,64.1 60,64.1 59.6,63.7 59.1,63.7 58.3,62.9 51.2,62.9 50.99,63.11
  BOTTOM w0.3: UNK2T21.1 50.99,63.11
LCD_BL_PWM: length 30
  TOP w0.102: v1(59.4,63.1) 59.4,62.6 60.1,61.9 60.1,58.9 59.7,58.5 59.7,57 60,56.7 v1(60,55.5)
  TOP w0.127: U1.C7 68.19,49.48 68.44,49.74 v2(68.45,49.74)
  BOTTOM w0.1: 51.1,62.2 51.4,62.5 58.5,62.5 59.1,63.1 v1(59.4,63.1) ; v1(60,55.5) 60.02,55.48 62.92,55.48 63.25,55.15 64.95,55.15 67.92,52.18 67.92,50.42 68.45,49.89 v2(68.45,49.74)
  BOTTOM w0.3: 51.1,62.2 UNK2T22.1
LCD_RESET: length 26.1
  TOP w0.1: v1(60.2,63.7) 60.96,62.94 60.96,57.54 61.3,57.2 61.3,54.01 62.07,53.24 62.07,52.43 63.51,50.99 63.51,50.41 64.12,49.8 64.47,49.8 64.8,49.47 U1.C2
  BOTTOM w0.1: 53.1,62.2 53.2,62.3 58.6,62.3 59,62.7 60.35,62.7 60.6,62.95 60.6,63.3 v1(60.2,63.7)
  BOTTOM w0.3: 53.1,62.2 UNK2T24.1
LINE_OUT_DET: length 25.4
  TOP w0.1: U1.D2 64.61,49.15 64.16,49.15 63.09,50.22 63.09,50.8 61.67,52.22 61.67,53.04 60.9,53.8 60.9,57 60.55,57.35 60.55,62.05 59.8,62.8 59.8,63.7 v1(59.4,64.1)
  BOTTOM w0.1: v1(59.4,64.1) 58.9,64.6 53.5,64.6 53.3,64.4
  BOTTOM w0.3: UNK2T23.1 53.3,64.4
LINUX_RX: length 23.7
  TOP w0.1: UNK2D4.1 66.91,65.21 UNK2R1.2
  TOP w0.102: UNK2D4.1 68.44,65.21 69.55,64.1 72.45,64.1 75.69,60.86 75.69,57 72,53.32 72,51.19 71.77,50.95 71.77,50.45 U1.B12
LINUX_TX: length 32.2
  TOP w0.1: v1(64.55,64.35) 64.25,64.35 63.85,64.75 UNK2D3.1 64.89,65.21 UNK2R16.2 ; v1(70.6,66.1) 69.7,66.1 69.2,65.6 69.2,64.8 69.65,64.35 71.4,64.35
  TOP w0.102: 71.4,64.35 72.5,64.35 75.9,60.95 75.9,56.91 72.22,53.23 72.22,50.9 U1.A13
  BOTTOM w0.1: v1(70.6,66.1) 70.3,66.1 69.8,65.6 69.3,65.6 68.3,64.6 64.8,64.6 v1(64.55,64.35)
LRCK: length 4.9
  BOTTOM w0.102: J813.10 89.18,8.77 88.05,9.9 87.25,9.9 86.2,10.95 UNK5R67.1
MCLK: length 5.8
  BOTTOM w0.1: J813.14 87.18,8.47 86.95,8.7 85.05,8.7 83.65,10.1 UNK5R70.1
MDDR3_VREF1: length 12.2
  TOP w0.3: v2(68.95,25.94) 68.96,25.94 UNK3U1.M8 ; UNK3U1.H1 63.28,29.53 v2(62.99,29.24)
  BOTTOM w0.254: 63.09,28.91 63.09,29.09 62.99,29.19 ; 63.09,28.91 64.36,27.64 65.17,27.64 66.42,26.39 67.46,26.39 67.96,25.9 UNK3C40.2 ; 63.09,28.91 62.99,29.01 62.99,29.19 ; 62.99,29.19 v2(62.99,29.24)
  BOTTOM w0.3: v2(62.99,29.24) 62.93,29.24 UNK3C27.2 UNK3R20.2 UNK3R19.1
  BOTTOM w0.4: v2(68.95,25.94) 68.91,25.9 UNK3C40.2
NAND_ALE: length 39.2
  TOP w0.1: 57.4,39.1 57.4,35.65 54.75,33 53.3,33 52.64,32.34 UNK4U5.17 52.64,30.44 51.8,29.6 47.4,29.6 v1(47.2,29.8) ; UNK4U9.U5 v1(48.5,40.1)
  TOP w0.102: 57.4,39.1 57.4,41.5 58.05,42.15 61.65,42.15 63.02,43.52 64.19,43.52 U1.M1
  BOTTOM w0.1: v1(48.5,40.1) 46.8,38.4 46.8,34.95 47.2,34.55 v1(47.2,29.8)
NAND_CLE: length 39.5
  TOP w0.1: 63.35,43.84 63.04,43.84 61.6,42.4 58,42.4 57.15,41.55 57.15,35.7 54.65,33.2 53.15,33.2 52.14,32.19 UNK4U5.16 52.14,30.24 51.7,29.8 48.05,29.8 v1(47.7,30.15) ; v1(49,39.55) 49.01,39.54 UNK4U9.W5
  TOP w0.102: U1.L2 64.61,43.94 64.08,43.94 63.98,43.84 63.35,43.84 63.35,43.84
  BOTTOM w0.1: v1(47.7,30.15) 47.4,30.45 47.4,34.95 UNK4R14.2 47,35.65 47,37.55 47.5,38.05 47.5,38.8 48.25,39.55 v1(49,39.55)
NAND_CS1: length 36.8
  TOP w0.1: v1(50.16,36) 50.51,36.35 50.51,38.1 UNK4U9.W6 ; v1(48.65,30.35) 48.64,30.36 UNK4U5.9 48.64,33.04 49,33.4 52.45,33.4 53,33.95 54.1,33.95 56.3,36.15 56.3,42.05 57.55,43.3 58.89,43.3 UNK4C3.2 UNK4R11.1 UNK4R11.2
  TOP w0.102: U1.L1 64.19,44.17 64.19,44.16 62.9,44.16 62.53,43.79 UNK4R11.2
  BOTTOM w0.1: v1(50.16,36) 49.26,35.1 UNK4R1.1 v1(48.65,30.35)
NAND_D0: length 28.6
  TOP w0.1: U1.F2 64.79,47.52 64.45,47.86 63.39,47.86 62.2,49.05 UNK4R19.2 UNK4R19.1 60.57,49.05 60.02,49.6 56,49.6 55.51,50.09 54.35,50.09 54.14,50.3 UNK4U5.29 54.14,52.74 v1(54.15,52.75) ; UNK4U9.H3 48.01,44.99 v1(48,45)
  BOTTOM w0.1: v1(48,45) 48.65,44.35 50.1,44.35 UNK4R16.2 50.9,46.3 51.1,46.5 51.1,50.8 51.51,51.21 53.76,51.21 54.15,51.6 v1(54.15,52.75)
NAND_D1: length 26.9
  TOP w0.1: v1(53.65,52.35) 53.64,52.34 UNK4U5.30 53.64,50.19 54.05,49.79 55.37,49.79 56.1,49.05 UNK4R20.1 UNK4R20.2 59.86,49.05 60.45,48.47 62.28,48.47 63.14,47.6 64.21,47.6 U1.F1 ; UNK4U9.H4 48.51,45.44 v1(48.5,45.45)
  BOTTOM w0.1: v1(53.65,52.35) 52.81,51.51 51.41,51.51 50.8,50.9 50.8,46.8 50.3,46.3 50.3,45.2 49.7,44.6 48.75,44.6 48.5,44.85 v1(48.5,45.45)
NAND_D2: length 26.2
  TOP w0.1: UNK4U9.H5 49.01,44.99 v1(49,45) ; v1(53.15,52.75) 53.14,52.74 UNK4U5.31 53.14,50.19 53.84,49.48 55.22,49.48 56.34,48.36 59.84,48.36 60.37,47.83 UNK4R21.1 UNK4R21.2 62.4,47.83 63.36,46.87 U1.G1
  BOTTOM w0.1: v1(53.15,52.75) 53.15,52.24 52.73,51.82 51.31,51.82 50.49,51 50.49,47.2 49.95,46.66 49.95,45.3 49.65,45 v1(49,45)
NAND_D3: length 29.6
  TOP w0.1: UNK4U9.J2 46.7,44.1 46.45,44.35 46.45,46 46.7,46.25 47.65,46.25 v1(48,46.6) ; v1(52.65,52.35) 52.64,52.34 UNK4U5.32 52.64,50.28 53.74,49.18 55.07,49.18 56.42,47.83 UNK4R22.1 UNK4R22.2 59.86,47.83 60.45,47.25 62.28,47.25 62.99,46.54 64.38,46.54 64.72,46.87 U1.G2
  BOTTOM w0.1: v1(52.65,52.35) 52.42,52.12 51.2,52.12 50.19,51.11 50.19,47.84 48.95,46.6 v1(48,46.6)
NAND_D4: length 31.3
  TOP w0.1: UNK4U9.J3 47.51,44.6 47.51,45.34 v1(47.05,45.8) ; U1.H2 64.62,45.9 63.93,45.9 63.5,46.33 62.12,46.33 UNK4R23.2 UNK4R23.1 60.58,46.61 59.94,47.25 56.55,47.25 54.93,48.87 53.64,48.87 52.76,49.75 48.59,49.75 48.14,50.21 UNK4U5.41 v1(48.14,52.35) 48.14,52.96 47.78,53.32 UNK4R52.2
  BOTTOM w0.1: v1(47.05,45.8) 47.05,46.25 47.6,46.8 47.6,51.81 v1(48.14,52.35)
NAND_D5: length 36.3
  TOP w0.1: UNK4U9.J4 47.51,43.1 46.05,43.1 45.7,43.45 v1(45.7,45.8) ; U1.J1 63.65,45.57 63.19,46.03 60.52,46.03 59.94,46.61 UNK4R24.2 UNK4R24.1 58.26,46.85 56.45,46.85 54.77,48.53 53.58,48.53 52.67,49.43 48.1,49.43 47.64,49.89 UNK4U5.42 v1(47.64,52.8) 47.64,52.84 46.9,53.58 UNK4R10.2
  BOTTOM w0.1: v1(45.7,45.8) 45.7,45.95 46.7,46.95 46.7,51.86 v1(47.64,52.8)
NAND_D6: length 34.6
  TOP w0.1: UNK4R13.2 45.77,53.15 46.9,53.15 47.14,52.91 UNK4U5.43 v1(47.14,50) 47.14,49.99 48,49.13 52.52,49.13 53.45,48.2 54.6,48.2 56.3,46.5 57.8,46.5 58.27,46.03 59.63,46.03 60.27,45.39 UNK4R25.1 UNK4R25.2 61.84,45.39 62.81,45.39 62.94,45.27 64.64,45.27 U1.J2 ; v1(49,43.1) 49.01,43.11 UNK4U9.J5
  BOTTOM w0.1: v1(47.14,50) 47.14,46.94 46.5,46.3 46.5,44.75 48.15,43.1 v1(49,43.1)
NAND_D7: length 39.8
  TOP w0.1: UNK4R2.2 44.8,52.9 46.47,52.9 v1(46.64,52.73) UNK4U5.44 46.64,49.81 47.63,48.82 52.33,48.82 53.25,47.9 54.35,47.9 56.1,46.15 57.85,46.15 58.5,45.5 UNK4R26.1 UNK4R26.2 59.88,44.91 62.58,44.91 62.59,44.92 U1.K1 ; v1(45.7,46.6) 46.2,47.1 48.75,47.1 50.51,45.34 50.51,44.6 50.01,44.1 UNK4U9.J6
  BOTTOM w0.1: v1(45.7,46.6) 46.39,47.29 46.39,51.94 46.64,52.19 v1(46.64,52.73)
NAND_NR/B: length 43
  TOP w0.1: v1(57.6,44.35) 55.7,42.45 55.7,39.5 55.1,38.9 55.1,36.2 53.7,34.8 52.65,34.8 52.1,34.25 48.6,34.25 47.6,33.25 47.6,32.6 47.64,32.56 UNK4U5.7 47.64,30.69 47.52,30.57 47.26,30.57 47.14,30.68 UNK4U5.6 47.14,32.91 v1(45.65,34.4)
  TOP w0.102: v2(65.91,44.59) 65.59,44.92 U1.K3
  BOTTOM w0.1: v1(45.65,34.4) 45.3,34.75 UNK4R12.1 UNK4R9.1 UNK4R17.1 ; 58.59,43.36 v1(57.6,44.35)
  BOTTOM w0.102: 58.59,43.36 62.2,43.36 62.83,43.99 63.14,43.99 63.83,44.68 64.43,44.68 64.63,44.88 65.62,44.88 v2(65.91,44.59)
NAND_NRE: length 25.9
  TOP w0.1: v1(55.5,38.75) 55.3,38.55 55.3,36.1 53.8,34.6 52.75,34.6 52.2,34.05 48.7,34.05 47.8,33.15 47.8,32.8 48.14,32.46 UNK4U5.8 ; UNK4R18.2 UNK4R18.1 58.95,40.85 v1(58.95,38.75)
  TOP w0.102: UNK4R18.2 61.39,41.6 63.09,43.29 64.61,43.29 U1.M2
  BOTTOM w0.1: v1(58.95,38.75) v1(55.5,38.75)
NAND_NWE: length 18.1
  TOP w0.1: UNK4R15.2 UNK4R15.1 59.35,40.15 59.35,37.25 54.9,32.8 53.5,32.8 53.14,32.44 UNK4U5.18
  TOP w0.102: UNK4R15.2 63.07,42.97 U1.N1
NAND_PSL: length 2.5
  TOP w0.102: UNK4U5.39 49.14,53.43 UNK4R3.2
NAND_VSP: length 3.5
  TOP w0.1: UNK4R8.2 50.21,53.16 v1(50.08,53.04)
  TOP w0.102: v1(50.08,53.04) 49.64,52.59 UNK4U5.38
  BOTTOM w0.1: UNK4R7.2 50.55,53.5 v1(50.08,53.04)
NPWM_OFF1: length 54.2
  TOP w0.1: R219.2 88.55,12.3 90.1,12.3 91.8,14 v1(92.9,14) ; v1(94.1,57.7) 94.1,35.95 v1(94.25,35.8) 94.1,35.65 94.1,23.65 93.5,23.05 93.5,20.25 v1(93.15,19.9)
  BOTTOM w0.1: v1(92.9,14) 93.3,14.4 93.3,19.75 v1(93.15,19.9)
  BOTTOM w0.2: v1(94.1,57.7) 94.85,57.7 95.18,57.37 U201.12 ; U202.12 95.18,35.62 95,35.8 v1(94.25,35.8)
NPWM_OFF2: length 39.6
  TOP w0.1: v1(35.7,49.4) 35.9,49.2 35.9,47.5 35.45,47.05 35.45,36.85 35.9,36.4 35.9,27.7 v1(35.7,27.5) 35.58,27.38 35.58,22.73 v1(35.77,22.52)
  BOTTOM w0.1: R320.2 42.8,26 41.6,24.8 39.25,24.8 36.6,22.15 36.15,22.15 v1(35.77,22.52)
  BOTTOM w0.2: v1(35.7,27.5) 35.2,27.5 34.87,27.83 U301.12 ; U302.12 34.87,49.63 35.1,49.4 v1(35.7,49.4)
NRESET_AMP: length 119.9
  TOP w0.1: v1(66.2,59.45) 66.54,59.11 66.54,53.77 67.41,52.91 67.41,51.18 67.21,50.99 67.21,50.45 U1.B6 ; v1(42.15,56.85) 42.55,56.45 42.55,27.45 43.85,26.15 46.3,26.15 47.15,25.3 v1(47.15,24.8) ; v1(66.4,17.3) 66.4,17.48 60.55,23.33 60.55,23.75 59.7,24.6 59.1,24.6 v1(58.7,25) ; R216.1 88.53,14.6 86.23,16.9 78.6,16.9 78.4,16.7 77.74,16.7 v1(77.34,16.3)
  BOTTOM w0.1: v1(77.34,16.3) 76.94,16.3 76.74,16.5 67.75,16.5 67.35,16.9 66.8,16.9 v1(66.4,17.3) ; v1(42.15,56.85) 42.35,57.05 52.9,57.05 54.1,58.25 54.1,59.15 54.5,59.55 57.1,59.55 57.4,59.25 66,59.25 v1(66.2,59.45) ; v1(58.7,25) 57.9,25.8 48.2,25.8 47.2,24.8 v1(47.15,24.8) R316.1
NRST_AMP1: length 52.6
  TOP w0.1: v1(92.9,14.6) R240.2 91.9,14.6 91.3,14 90.55,14 R215.2 R216.2 ; v1(92.5,19.9) 93.3,20.7 93.3,23.45 v1(93.45,23.6) 93.85,24 93.85,45.3 v1(93.7,45.45)
  BOTTOM w0.1: v1(92.9,14.6) 93.05,14.75 93.05,19.35 v1(92.5,19.9)
  BOTTOM w0.2: v1(93.45,23.6) 93.45,23.55 93.5,23.5 94.7,23.5 94.85,23.65 94.85,24.55 95.35,25.05 C226.2 96.68,25.61 U202.36 ; v1(93.7,45.45) 94.6,45.45 94.9,45.75 94.9,46.55 95.35,47 C204.2 96.68,47.56 U201.36
